# Repository farzin-db70/imuGpsMos

## KiCad design circuit/IMU.kicad_pcb

Parts:
AE1: Antenna_Shield; U.FL_Hirose_U.FL-R-SMT-1_Vertical
C1, C3, C4, C8, C10, C13: 100nF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C2, C6: 10nF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C5: 2.2NF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C7: 4.7uF; CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder
C9: 220nF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C11, C12: 10uF; CP_EIA-3216-18_Kemet-A
CP1: 10uF; CP_EIA-3216-18_Kemet-A
D1: 1N5822; D_SMA
J1: JST-2PIN-2mm; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J2, J3, J4, J5: JSE-2PIN-2mm; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
L1: 27nH; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
Q1, Q2, Q3, Q4: AO3400A; SOT-23
R1, R2, R3: 2K2; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R4, R5: 100R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R6: 10R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R7, R8, R9, R10, R11: 10K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U1: MPU-6050; InvenSense_QFN-24_4x4mm_P0.5mm
U2: NEO-M8N; ublox_NEO
U3: HMC5883L; LFCSP-16-1EP_3x3mm_P0.5mm_EP1.7x1.7mm
U4: BMP280; Bosch_LGA-8_2x2.5mm_P0.65mm_ClockwisePinNumbering
U5: AP2112K-3.3; SOT-23-5
U6: ESP32-DEVKITC-32D; MODULE_ESP32-DEVKITC-32D; PARTREV 4

Connections:
+3.3VA: C4.2, CP1.1, U2.22 (V_BCKP), U2.23 (VCC), U6.1 (3V3)
+3V3: C1.2, C2.2, C8.2, C10.2, C12.1, C13.2, R1.2, R2.2, R3.2, U1.8 (VDDIO), U1.13 (VDD), U3.2 (VDD), U3.4 (S1), U3.13 (VDDIO), U4.6 (VDDIO), U4.8 (VDD), U5.5
+5V: C11.1, D1.1, J2.1, J3.2, J4.1, J5.2, R9.2, U5.1, U6.19 (EXT_5V)
/BMP_CSB: U4.2 (CSB), U6.29 (IO5)
/BMP_SCK: U4.4 (SCK), U6.28 (IO18)
/BMP_SDI: U4.3 (SDI), U6.21 (IO23)
/BMP_SDO: U4.5 (SDO), U6.27 (IO19)
/GPS_INT: U2.4 (EXTINT), U6.8 (IO33)
/GPS_RST: U2.8 (~RESET), U6.10 (IO26)
/GPS_RXD: R5.2, U6.23 (TXD0)
/GPS_S_SEL: U2.2 (D_SEL), U6.7 (IO32)
/GPS_TIMEPULSE: U2.3 (TIMEPULSE), U6.3 (SENSOR_VP)
/GPS_TXD: R4.2, U6.24 (RXD0)
/I2C0_SCL: R1.1, U1.23 (SCL), U3.1 (SCL), U6.22 (IO22)
/I2C0_SDA: R2.1, U1.24 (SDA), U3.16 (SDA), U6.25 (IO21)
/MPU_INT: R3.1, U1.12 (INT), U6.35 (IO15)
/Motor1: Q1.1 (G), R7.2, U6.32 (IO4)
/Motor2: Q2.1 (G), R8.2, U6.30 (IO17)
/Motor3: Q3.1 (G), R10.2, U6.9 (IO25)
/Motor4: Q4.1 (G), R11.2, U6.11 (IO27)
GND: AE1.2 (Shield), C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C10.1, C11.2, C12.2, C13.1, CP1.2, J1.2, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), R7.1, R8.1, R10.1, R11.1, U1.1 (CLKIN), U1.9 (AD0), U1.11 (FSYNC), U1.18 (GND), U2.7 (VDD_USB), U2.10 (GND), U2.12 (GND), U2.13 (GND), U2.24 (GND), U3.9 (GND@1), U3.11 (GND@2), U4.1 (GND), U4.7 (GND), U5.2, U6.14 (GND1), U6.20 (GND3), U6.26 (GND2)
unnamed: AE1.1 (A), L1.2, U2.11 (RF_IN)
unnamed: C3.2, U1.10 (REGOUT)
unnamed: C5.2, U1.20 (CPOUT)
unnamed: C6.2, L1.1, R6.1
unnamed: C7.2, U3.10 (C1)
unnamed: C9.1, U3.12 (SETC)
unnamed: C9.2, U3.8 (SETP)
unnamed: D1.2, J1.1
unnamed: J2.2, Q1.3 (D)
unnamed: J3.1, Q2.3 (D)
unnamed: J4.2, Q3.3 (D)
unnamed: J5.1, Q4.3 (D)
unnamed: R4.1, U2.20 (TXD/SPI_MISO)
unnamed: R5.1, U2.21 (RXD/SPI_MOSI)
unnamed: R6.2, U2.9 (VCC_RF)
unnamed: R9.1, U5.3

Notes on the sheet:
Sensors
GPS
GPS supply
OutPut

Board: 2 copper layers, 27.9 x 54.4 mm, 43 parts (0 on the bottom side), 37 nets.

## Commit log

2021-10-20 first commit: add circuit and pcb
